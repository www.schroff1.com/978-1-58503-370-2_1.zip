# Autodesk Inventor part: stretch
## iProperties
Created: 2007-02
Part Number: stretch
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
