# Autodesk Inventor part: constraint1
## iProperties
Created: 2002-01
Part Number: constraint1
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
