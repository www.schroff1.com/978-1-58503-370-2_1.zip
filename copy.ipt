# Autodesk Inventor part: copy
## iProperties
Created: 2007-02
Part Number: copy
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
