# Autodesk Inventor part: constraint2
## iProperties
Created: 2002-01
Part Number: constraint2
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
